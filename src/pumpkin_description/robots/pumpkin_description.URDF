Commit message: Another small change

File: src/pumpkin_description/robots/pumpkin_description.URDF (robot description, URDF)
Before this commit: robot pumpkin_description, 18 links, 17 joints
Joints:
- joint l_elbow: axis 0 0 -1 -> 0 0 1
